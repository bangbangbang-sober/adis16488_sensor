# Keil uVision project uavcan.uvprojx, settings and files
target uvacan (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uavcan +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVE
  c misc: --C99
  c include: .\source;.\source\code;.\source\header;.\source\Libraries\CMSIS;.\source\Libraries\CMSIS\Include;.\source\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\source\Libraries;.\source\ADIS16488A;.\source\UAVCAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group header
    ./source/header/: can.h gpio.h spi.h tim.h
    ./source/UAVCAN/: uavcan.h
    ./source/ADIS16488A/: ADIS16488A.H adis.h
  group code
    ./source/code/: can.c gpio.c main.c spi.c tim.c
    ./source/: system_stm32f4xx.c
    ./source/UAVCAN/: uavcan.c
    ./source/ADIS16488A/: ADIS16488A.C
  group CMSIS
    ./source/: stm32f4xx_it.c stm32f4xx_conf.h
    ./source/Libraries/: startup_stm32f40xx.s stm32f4xx.h
  group STM32F4xx_StdPeriph_Driver
    ./source/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_hash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
